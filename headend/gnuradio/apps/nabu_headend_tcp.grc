options:
  parameters:
    author: Brian Johnson
    category: '[NABU Headend]'
    copyright: 2026 Brian Johnson
    description: Live NABU headend carousel, OQPSK-modulated, served as a cs8 TCP stream
    generate_options: no_gui
    id: nabu_headend_tcp
    output_language: python
    run_options: run
    title: NABU Headend TCP Stream
  states: {}

blocks:
- name: pulse_taps
  id: variable
  parameters:
    value: (0.7 * np.sin(np.pi * np.arange(sps) / sps)).tolist()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 3.156e6
  states: {}
- name: config
  id: parameter
  parameters:
    label: Config file
    short_id: c
    type: str
    value: headend.yaml
  states: {}
- name: diff_i
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: diff_q
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: join_iq
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: tcp_stream
  id: network_tcp_sink
  parameters:
    addr: 0.0.0.0
    mode: '2'
    port: '5816'
    type: byte
  states: {}
- name: map_i
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: map_q
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: q_offset
  id: blocks_delay
  parameters:
    delay: sps // 2
    type: float
  states: {}
- name: shape_i
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pulse_taps
    type: fff
  states: {}
- name: shape_q
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: pulse_taps
    type: fff
  states: {}
- name: split_iq
  id: blocks_deinterleave
  parameters:
    comment: |-
      deinterleave each pair of bits
      first = I
      second = Q
    type: byte
  states: {}
- name: to_cs8
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {}
- name: unpack
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: wheel
  id: nabu_headend_wheel_source
  parameters:
    comment: packed line bytes
    config_file: config
  states: {}

connections:
- [diff_i, '0', map_i, '0']
- [diff_q, '0', map_q, '0']
- [join_iq, '0', to_cs8, '0']
- [map_i, '0', shape_i, '0']
- [map_q, '0', shape_q, '0']
- [q_offset, '0', join_iq, '1']
- [shape_i, '0', join_iq, '0']
- [shape_q, '0', q_offset, '0']
- [split_iq, '0', diff_i, '0']
- [split_iq, '1', diff_q, '0']
- [to_cs8, '0', tcp_stream, '0']
- [unpack, '0', split_iq, '0']
- [wheel, '0', unpack, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
